# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::.\ArmCC5)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: .\inc;.\driverlib;.;.\User\base;.\User\app
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c
  group DriverLib
    ./driverlib/rvmdk/: driverlib.lib
  group User
    ./User/: callback.c
  group User/base
    ./User/base/: board.c delay.c hibernate_rtc.c i2c_bus.c pwm_buzzer.c stepper.c timebase.c uart_port.c
  group User/app
    ./User/app/: alarm.c app.c app_state.c boot_sequence.c button_logic.c command.c datetime.c display.c melody.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
